INCLUDE<P16F877A.INC>
__config H'3F31'

SAYAC1 EQU 0X25
SAYAC2 EQU 0X26
a equ 0x27
ORG 0X00
goto anaprogram

ORG 0X04
KESME
RETFIE



anaprogram
BANKSEL TRISB
CLRF TRISB
CLRF TRISC
movlw 0x06
movwf ADCON1
MOVLW D'00'
MOVWF TRISA
BANKSEL PORTB
CLRF PORTB
CLRF PORTC
clrf a


ilk
MOVLW D'1'
MOVWF PORTC
MOVLW B'00111111'
MOVWF PORTB
call gecikme

MOVLW D'2'
MOVWF PORTC
MOVLW B'00000110'
MOVWF PORTB
call gecikme
goto ilk


gecikme
MOVLW H'FF'
MOVWF SAYAC1
DECFSZ SAYAC1,F
GOTO $-1
RETURN






END