INCLUDE <P16F877A.INC>
SAYAC EQU 0X21
ORG 0X00
GOTO ANAPROGRAM
ORG 0X04
BANKSEL PIR1
BTFSS PIR1,TMR1IF
RETFIE
BCF PIR1,TMR1IF
BANKSEL TMR1H
MOVLW 0X3C
MOVWF TMR1H
MOVLW 0XB0
MOVWF TMR1L
INCF SAYAC,F
MOVF SAYAC,W
SUBLW D'5'
BTFSS STATUS,Z
RETFIE
COMF PORTB,F
CLRF SAYAC
RETFIE



ANAPROGRAM
BANKSEL PORTB
CLRF PORTB
BANKSEL TRISB
CLRF TRISB
CLRF SAYAC
BANKSEL TMR1H
MOVLW 0X3C
MOVWF TMR1H
MOVLW 0XB0
MOVWF TMR1L
BANKSEL T1CON
MOVLW B'00100001'
MOVWF T1CON
BANKSEL INTCON
BSF INTCON,GIE
BSF INTCON,PEIE
BANKSEL PIE1
BSF PIE1,TMR1IE
SONSUZ

GOTO SONSUZ

END
